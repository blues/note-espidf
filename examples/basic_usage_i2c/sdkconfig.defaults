## examples/basic_usage_i2c/sdkconfig.defaults
```kconfig
# Notecard Configuration for I2C Example
CONFIG_NOTECARD_LOGGING=y
CONFIG_NOTEHUB_PRODUCT_UID="com.your-company.your-name:your-project"
```
